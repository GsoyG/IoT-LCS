<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\SmartLight.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>ALL</name>
      <member>
        <project>SmartLight</project>
        <configuration>CoordinatorEB</configuration>
      </member>
      <member>
        <project>SmartLight</project>
        <configuration>RouterEB</configuration>
      </member>
      <member>
        <project>SmartLight</project>
        <configuration>EndDeviceEB</configuration>
      </member>
      <member>
        <project>SmartLight</project>
        <configuration>RouterZLight</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>


